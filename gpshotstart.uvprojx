# Keil uVision project gpshotstart.uvprojx, settings and files
target stm32f417 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F417VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpshotstart
  c flags: Optim=1 wLevel=2
  c define: inline=__inline,USE_STDPERIPH_DRIVER
  c include: .\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries;.\inc;.\Libraries\mbed\api;.\Libraries\mbed\hal;.\Libraries\mbed\targets\hal\TARGET_STM\TARGET_STM32F4XX;.\Libraries\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4XX
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/: main.cpp ubloxOp.cpp
  group startup
    ./startup/: startup_stm32f40xx.s
  group system
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group periferals
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group mbed
    ./Libraries/mbed/common/: assert.c gpio.c board.c error.c pinmap_common.c us_ticker_api.c wait_api.c Serial.cpp SerialBase.cpp
    ./Libraries/mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4XX/: cmsis_nvic.c
    ./Libraries/mbed/targets/hal/TARGET_STM/TARGET_STM32F4XX/: us_ticker.c pinmap.c gpio_api.c
